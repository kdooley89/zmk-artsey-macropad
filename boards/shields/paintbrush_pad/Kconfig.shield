## boards/shields/paintbrush_pad/Kconfig.shield
```kconfig
# SPDX-License-Identifier: MIT

config SHIELD_PAINTBRUSH_PAD
    def_bool $(shields_list_contains,paintbrush_pad)
```
